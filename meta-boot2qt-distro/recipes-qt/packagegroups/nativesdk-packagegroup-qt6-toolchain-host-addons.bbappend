RDEPENDS:${PN} += " \
    nativesdk-qtgrpc-dev \
    nativesdk-qtgrpc-tools \
"
