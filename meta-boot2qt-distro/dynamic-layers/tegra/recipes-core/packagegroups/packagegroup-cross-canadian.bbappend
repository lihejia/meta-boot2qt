RDEPENDS:${PN}:remove:tegra = " gcc-for-nvcc-cross-canadian-${TRANSLATED_TARGET_ARCH}"
