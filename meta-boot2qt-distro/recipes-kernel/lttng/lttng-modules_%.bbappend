FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-fix-mm-slab_common-drop-kmem_alloc-avoid-dereferenci.patch"
